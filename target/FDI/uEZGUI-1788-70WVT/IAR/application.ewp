# IAR project application.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC1788 NXP LPC1788
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NXP; NDEBUG; USE_BPP=16
  ICCARM.CCIncludePath2: ..\..\..\..\platform\os; ..\..\..\..\gui\include; ..\..\..\..\target\include; ..\..\..\..\generated\fonts\include; ..\..\..\..\generated\images\include; ..\..\..\..\generated\texts\include; ..\..\..\..\generated\gui_generated\include; ..\..\..\..\..\..\..\touchgfx\framework\include; ..\..\..\..\..\..\..\touchgfx\framework\include\platform\core\arm\cortex-m\CMSIS; ..\..\..\..\..\..\..\touchgfx\framework\include\platform\hal\nxp\mcu\LPC17xx\vendor; ..\..\..\..\..\..\..\touchgfx\board\FDI\uEZGUI-1788-70WVT\include; ..\..\..\..\..\..\..\touchgfx\board\FDI\uEZGUI-1788-70WVT\include\vendor; ..\..\..\..\..\..\..\touchgfx\os\FreeRTOS7.6.0\Source\include; ..\..\..\..\..\..\..\touchgfx\os\FreeRTOS7.6.0\Source\portable\IAR\ARM_CM3
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.AUserIncludes: ..\..\..\..\platform\os\
  OBJCOPY.OOCOutputFile: application.bin
  ILINK.IlinkOutputFile: application.out
  ILINK.IlinkIcfFile: application.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\..\..\touchgfx\lib\core\cortex_m3\IAR\touchgfx_core.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/generated/fonts
    ../../../../generated/fonts/src/: ApplicationFontProvider.cpp
  group Application/generated/images
    ../../../../generated/images/src/: BitmapDatabase.cpp
  group Application/generated/texts
    ../../../../generated/texts/src/: Texts.cpp TypedTextDatabase.cpp
  group Application/gui/common
    ../../../../gui/src/common/: FrontendApplication.cpp
  group Application/gui/model
    ../../../../gui/src/model/: Model.cpp
  group Application/gui/template_screen
    ../../../../gui/src/template_screen/: TemplatePresenter.cpp TemplateView.cpp
  group Application/main
    ../../../: main.cpp
  group Board
    ../../../../../../../touchgfx/board/FDI/uEZGUI-1788-70WVT/source/: BoardConfiguration.cpp GPIO.cpp
  group Board/uEZGUI-1788-70WVT/Driver
    ../../../../../../../touchgfx/board/FDI/uEZGUI-1788-70WVT/source/bsp/: ResistiveTouchController.cpp
  group Board/uEZGUI-1788-70WVT/Vendor
    ../../../../../../../touchgfx/board/FDI/uEZGUI-1788-70WVT/source/vendor/: FDI_LCD.cpp FDI_Memory.cpp FDI_RTC.cpp FDI_Touch.cpp
  group MCU
    ../../../../../../../touchgfx/framework/source/platform/hal/nxp/mcu/LPC17xx/: NXP1788DMA.cpp NXP1788HAL.cpp
  group MCU/LPC1788
    ../../../../../../../touchgfx/framework/source/platform/hal/nxp/mcu/LPC17xx/vendor/: debug_frmwrk.c lpc177x_8x_adc.c lpc177x_8x_can.c lpc177x_8x_clkpwr.c lpc177x_8x_crc.c lpc177x_8x_dac.c lpc177x_8x_eeprom.c lpc177x_8x_emc.c lpc177x_8x_exti.c lpc177x_8x_gpdma.c lpc177x_8x_gpio.c lpc177x_8x_i2c.c lpc177x_8x_i2s.c lpc177x_8x_lcd.c lpc177x_8x_mci.c lpc177x_8x_mcpwm.c lpc177x_8x_nvic.c lpc177x_8x_pinsel.c lpc177x_8x_pwm.c lpc177x_8x_qei.c lpc177x_8x_rtc.c lpc177x_8x_ssp.c lpc177x_8x_systick.c lpc177x_8x_timer.c lpc177x_8x_uart.c lpc177x_8x_usbhost.c lpc177x_8x_wwdt.c system_LPC177x_8x.c
    ../../../../../../../touchgfx/framework/source/platform/hal/nxp/mcu/LPC17xx/IAR/: startup_LPC17xx.s
  group OS
    ../../../../../../../touchgfx/os/FreeRTOS7.6.0/: OSWrappers.cpp
  group OS/FreeRTOS7.6.0
    ../../../../../../../touchgfx/os/FreeRTOS7.6.0/Source/: croutine.c list.c queue.c tasks.c timers.c
    ../../../../../../../touchgfx/os/FreeRTOS7.6.0/Source/portable/MemMang/: heap_2.c
  group OS/FreeRTOS7.6.0/portable
    ../../../../../../../touchgfx/os/FreeRTOS7.6.0/Source/portable/IAR/ARM_CM3/: port.c portasm.s
