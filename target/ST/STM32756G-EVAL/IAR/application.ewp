# IAR project application.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F429NI ST STM32F429NI
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: ST; STM32F756xx; USE_FREERTOS_8; USE_OS_SYSTICK; USE_IOEXPANDER; USE_BPP=16
  ICCARM.CCIncludePath2: ..\..\..\..\gui\include; ..\..\..\..\target\include; ..\..\..\..\platform\os; ..\..\..\..\generated\fonts\include; ..\..\..\..\generated\images\include; ..\..\..\..\generated\texts\include; ..\..\..\..\generated\gui_generated\include; ..\..\..\..\..\..\..\touchgfx\framework\include; ..\..\..\..\..\..\..\touchgfx\framework\include\platform\core\arm\cortex-m\CMSIS; ..\..\..\..\..\..\..\touchgfx\framework\include\platform\hal\ST\mcu\stm32f7xx\STM32F7xx_HAL_Driver; ..\..\..\..\..\..\..\touchgfx\framework\include\platform\hal\ST\mcu\stm32f7xx\CMSIS; ..\..\..\..\..\..\..\touchgfx\board\ST\STM32756G-EVAL\include; ..\..\..\..\..\..\..\touchgfx\board\ST\STM32756G-EVAL\include\vendor; ..\..\..\..\..\..\..\touchgfx\board\ST\STM32756G-EVAL\source\vendor\STM32756G_EVAL; ..\..\..\..\..\..\..\touchgfx\os\FreeRTOS8.2.0\Source\include; ..\..\..\..\..\..\..\touchgfx\os\FreeRTOS8.2.0\Source\portable\IAR\ST_CM7
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: USE_FREERTOS_8; USE_OS_SYSTICK
  AARM.AUserIncludes: ..\..\..\..\platform\os; ..\..\..\..\..\framework\touchgfx\platform\core\arm\cortex-m\CMSIS\include; ..\..\..\..\..\framework\touchgfx\platform\hal\ST\board\STM32429I-EVAL1\include; ..\..\..\..\..\framework\touchgfx\platform\hal\ST\board\STM32429I-EVAL1\src; ..\..\..\..\..\framework\touchgfx\platform\hal\ST\mcu\stm32f4x9\inc; ..\..\..\..\..\framework\touchgfx\platform\os\FreeRTOS7.6.0\Source\include; ..\..\..\..\..\framework\touchgfx\platform\os\FreeRTOS7.6.0\Source\portable\IAR\ARM_CM4F
  OBJCOPY.OOCOutputFile: application.hex
  ILINK.IlinkOutputFile: application.out
  ILINK.IlinkIcfFile: application.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\..\..\touchgfx\lib\core\cortex_m7\IAR\touchgfx_core.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/generated/fonts
    ../../../../generated/fonts/src/: ApplicationFontProvider.cpp
  group Application/generated/images
    ../../../../generated/images/src/: BitmapDatabase.cpp
  group Application/generated/texts
    ../../../../generated/texts/src/: Texts.cpp TypedTextDatabase.cpp
  group Application/gui/common
    ../../../../gui/src/common/: FrontendApplication.cpp
  group Application/gui/model
    ../../../../gui/src/model/: Model.cpp
  group Application/gui/template_screen
    ../../../../gui/src/template_screen/: TemplatePresenter.cpp TemplateView.cpp
  group Application/main
    ../../../: main.cpp
  group Board/STM32756G-EVAL
    ../../../../../../../touchgfx/board/ST/STM32756G-EVAL/source/: BoardConfiguration.cpp GPIO.cpp
  group Board/STM32756G-EVAL/BSP
    ../../../../../../../touchgfx/board/ST/STM32756G-EVAL/source/bsp/: STM32756GTouchController.cpp STM32F7Instrumentation.cpp
  group Board/STM32756G-EVAL/Vendor
    ../../../../../../../touchgfx/board/ST/STM32756G-EVAL/source/vendor/Components/exc7200/: exc7200.c
    ../../../../../../../touchgfx/board/ST/STM32756G-EVAL/source/vendor/Components/mfxstm32l152/: mfxstm32l152.c
    ../../../../../../../touchgfx/board/ST/STM32756G-EVAL/source/vendor/STM32756G_EVAL/: stm32756g_eval.c stm32756g_eval_io.c stm32756g_eval_lcd.c stm32756g_eval_qspi.c stm32756g_eval_sdram.c stm32756g_eval_ts.c
    ../../../../../../../touchgfx/board/ST/STM32756G-EVAL/source/vendor/Components/stmpe811/: stmpe811.c
    ../../../../../../../touchgfx/board/ST/STM32756G-EVAL/source/vendor/Components/ts3510/: ts3510.c
  group MCU
    ../../../../../../../touchgfx/framework/source/platform/hal/ST/mcu/stm32f7xx/: STM32F7DMA.cpp STM32F7HAL.cpp
  group MCU/stm32f7xx
    ../../../../../../../touchgfx/framework/source/platform/hal/ST/mcu/stm32f7xx/IAR/: startup_stm32f756xx.s
    ../../../../../../../touchgfx/framework/source/platform/hal/ST/mcu/stm32f7xx/STM32F7xx_HAL_Driver/: stm32f7xx_hal.c stm32f7xx_hal_adc.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_can.c stm32f7xx_hal_cec.c stm32f7xx_hal_cortex.c stm32f7xx_hal_crc.c stm32f7xx_hal_crc_ex.c stm32f7xx_hal_cryp.c stm32f7xx_hal_cryp_ex.c stm32f7xx_hal_dac.c stm32f7xx_hal_dac_ex.c stm32f7xx_hal_dcmi.c stm32f7xx_hal_dcmi_ex.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_eth.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_hash.c stm32f7xx_hal_hash_ex.c stm32f7xx_hal_hcd.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_i2s.c stm32f7xx_hal_irda.c stm32f7xx_hal_iwdg.c stm32f7xx_hal_lptim.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_msp_template.c stm32f7xx_hal_nand.c stm32f7xx_hal_nor.c stm32f7xx_hal_pcd.c stm32f7xx_hal_pcd_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_qspi.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_rng.c stm32f7xx_hal_rtc.c stm32f7xx_hal_rtc_ex.c stm32f7xx_hal_sai.c stm32f7xx_hal_sai_ex.c stm32f7xx_hal_sd.c stm32f7xx_hal_sdram.c stm32f7xx_hal_smartcard.c stm32f7xx_hal_smartcard_ex.c stm32f7xx_hal_spdifrx.c stm32f7xx_hal_spi.c stm32f7xx_hal_sram.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_usart.c stm32f7xx_hal_wwdg.c stm32f7xx_ll_fmc.c stm32f7xx_ll_sdmmc.c stm32f7xx_ll_usb.c
    ../../../../../../../touchgfx/framework/source/platform/hal/ST/mcu/stm32f7xx/CMSIS/: system_stm32f7xx.c
  group OS
    ../../../../../../../touchgfx/os/FreeRTOS8.2.0/: OSWrappers.cpp
  group OS/FreeRTOS8.2.0
    ../../../../../../../touchgfx/os/FreeRTOS8.2.0/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../../../../../../../touchgfx/os/FreeRTOS8.2.0/Source/portable/MemMang/: heap_2.c
    ../../../../../../../touchgfx/os/FreeRTOS8.2.0/Source/portable/IAR/ST_CM7/: port.c portasm.s
