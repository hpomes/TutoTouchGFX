# Keil uVision project application.uvproj, settings and files
target Internal flash and NOR (ARM-ADS)
  device: Cortex-M4 FPU ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE FPU2
  output: application +hex
  c flags: Optim=1
  c define: ST USE_STDPERIPH_DRIVER STM32F469xx USE_STM32469I_EVAL USE_FLOATING_POINT USE_OS_SYSTICK USE_IOEXPANDER USE_BPP=16
  c include: ..\..\..\..\gui\include;..\..\..\..\target\include;..\..\..\..\platform\os;..\..\..\..\generated\fonts\include;..\..\..\..\generated\images\include;..\..\..\..\generated\texts\include;..\..\..\..\generated\gui_generated\include;..\..\..\..\..\..\..\touchgfx\framework\include;..\..\..\..\..\..\..\touchgfx\framework\include\platform\core\arm\cortex-m\CMSIS;..\..\..\..\..\..\..\touchgfx\framework\include\platform\hal\ST\mcu\stm32f4cube;..\..\..\..\..\..\..\touchgfx\framework\include\platform\hal\ST\mcu\stm32f4cube\STM32F4xx_HAL_Driver;..\..\..\..\..\..\..\touchgfx\framework\include\platform\hal\ST\mcu\stm32f4cube\CMSIS;..\..\..\..\..\..\..\touchgfx\board\ST\STM32469I-EVAL\include;..\..\..\..\..\..\..\touchgfx\board\ST\STM32469I-EVAL\include\bsp;..\..\..\..\..\..\..\touchgfx\board\ST\STM32469I-EVAL\source\vendor\STM32469I_EVAL;..\..\..\..\..\..\..\touchgfx\os\FreeRTOS7.6.0\Source\include;..\..\..\..\..\..\..\touchgfx\os\FreeRTOS7.6.0\Source\portable\RVDS\ARM_CM4F
  asm include: ..\..\..\..\platform\os
  scatter file: .\Flash.sct
  group Startup
    ../../../../../../../touchgfx/framework/source/platform/hal/ST/mcu/stm32f4cube/Keil/: startup_stm32f469xx.s
    ../../../: main.cpp
  group Gui
    ../../../../gui/src/common/: FrontendApplication.cpp
    ../../../../gui/src/model/: Model.cpp
    ../../../../gui/src/template_screen/: TemplatePresenter.cpp TemplateView.cpp
  group Generated
    ../../../../generated/fonts/src/: ApplicationFontProvider.cpp
    ../../../../generated/images/src/: BitmapDatabase.cpp
    ../../../../generated/texts/src/: Texts.cpp TypedTextDatabase.cpp
  group TouchGFXHAL
    ../../../../../../../touchgfx/framework/source/platform/core/arm/cortex-m/: CortexMMCUInstrumentation.cpp
    ../../../../../../../touchgfx/framework/source/platform/hal/ST/mcu/stm32f4cube/: STM32F4DMA.cpp STM32F4HAL_DSI.cpp
    ../../../../../../../touchgfx/board/ST/STM32469I-EVAL/source/: BoardConfiguration.cpp GPIO.cpp
    ../../../../../../../touchgfx/board/ST/STM32469I-EVAL/source/bsp/: OTM8009TouchController.cpp
  group HAL
    ../../../../../../../touchgfx/framework/source/platform/hal/ST/mcu/stm32f4cube/CMSIS/: system_stm32f4xx.c
    ../../../../../../../touchgfx/framework/source/platform/hal/ST/mcu/stm32f4cube/STM32F4xx_HAL_Driver/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_dsi.c stm32f4xx_hal_eth.c stm32f4xx_hal_flash.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_qspi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_sai.c stm32f4xx_hal_sdram.c stm32f4xx_hal_tim.c stm32f4xx_ll_fsmc.c stm32f4xx_ll_fmc.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_uart.c
    ../../../../../../../touchgfx/board/ST/STM32469I-EVAL/source/vendor/STM32469I_EVAL/: stm32469i_eval.c stm32469i_eval_lcd.c stm32469i_eval_qspi.c stm32469i_eval_sdram.c stm32469i_eval_ts.c stm32469i_eval_io.c
    ../../../../../../../touchgfx/board/ST/STM32469I-EVAL/source/vendor/Components/otm8009a/: otm8009a.c
    ../../../../../../../touchgfx/board/ST/STM32469I-EVAL/source/vendor/Components/ft6x06/: ft6x06.c
    ../../../../../../../touchgfx/board/ST/STM32469I-EVAL/source/vendor/Components/mfxstm32l152/: mfxstm32l152.c
  group OS
    ../../../../../../../touchgfx/os/FreeRTOS7.6.0/Source/: croutine.c list.c queue.c tasks.c timers.c
    ../../../../../../../touchgfx/os/FreeRTOS7.6.0/Source/portable/MemMang/: heap_2.c
    ../../../../../../../touchgfx/os/FreeRTOS7.6.0/: OSWrappers.cpp
    ../../../../../../../touchgfx/os/FreeRTOS7.6.0/Source/portable/RVDS/ARM_CM4F/: port.c
  group Lib
    ../../../../../../../touchgfx/lib/core/cortex_m4f/Keil/: touchgfx_core.lib
